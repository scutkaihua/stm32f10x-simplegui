# Keil uVision project stm32-simplegui.uvproj, settings and files
target stm32-simplegui (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32-simplegui
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\simple-gui\GUI\inc;..\simple-gui\HMI\inc;..\simple-gui\DemoProc\inc;..\simple-gui\portable\inc;..\cpu\inc;..\cpu\Core\inc;..\cpu;..\dev
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../app/: main.c
  group dev
    ../dev/: dev.c gpio.c driver_config.c
  group sgui-portable
    ../simple-gui/portable/src/: YLF320240A.c base_timer.c keyboard.c led.c rtc.c screen.c spi_flash.c ssd1306_spi.c trigger_flags.c uc1604c_softspi.c usart.c usart_stdio.c
  group sgui-gui
    ../simple-gui/GUI/src/: SGUI_Basic.c SGUI_Common.c SGUI_Curve.c SGUI_FontResource.c SGUI_IconResource.c SGUI_Interface.c SGUI_ItemsBase.c SGUI_List.c SGUI_Menu.c SGUI_Notice.c SGUI_ProcessBar.c SGUI_RealtimeGraph.c SGUI_ScrollBar.c SGUI_Text.c SGUI_VariableBox.c
  group sgui-hmi
    ../simple-gui/HMI/src/: HMI_Engine.c
  group sgui-demoproc
    ../simple-gui/DemoProc/src/: Basic.c Curve.c DemoProc.c List.c Menu.c Notice.c RealtimeGraph.c Resource.c Text.c VariableBox.c
  group cpu
    ../cpu/: cpu.c stm32io.c
    E:/stm32f10x-simplegui/src/cpu/: STM32F10x.s
    ../cpu/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
